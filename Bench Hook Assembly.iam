# Autodesk Inventor assembly: Bench Hook Assembly
## iProperties
Created: 2010-02
Part Number: Bench Hook Assembly
Document SubType Name: Assembly
Designer: Munford
Author: Munford
